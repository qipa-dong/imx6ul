# IAR project Backup of hello_world.ewp, settings and files
configuration ddr_debug (ARM, debug)
  General.OGChipSelectEditMenu: MCIMX6G2 NXP MCIMX6G2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MCIMX6G2DVM05; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; EVK_MCIMX6UL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\CORTEXA\Include; ..\..\devices; ..; ../../..; ..\..\devices\MCIMX6G2\drivers; ../../../../../platform/utilities/debug_console; ../../../../../platform/utilities/debug_console/io; ../../../../../platform/utilities/debug_console/str; ..\..\devices\MCIMX6G2\utilities; ..\..\devices\MCIMX6G2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: hello_world.bin
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  ICCARM.CCDefines: DEBUG; CPU_MCIMX6G3DVM05; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; EVK_MCIMX6UL
  ICCARM.CCIncludePath2: ../../../../../CORTEXA/Include; ../../../../../devices; ..; ../../..; ../../../../../devices/MCIMX6G3/drivers; ../../../../../platform/utilities/debug_console; ../../../../../platform/utilities/debug_console/io; ../../../../../platform/utilities/debug_console/str; ../../../../../devices/MCIMX6G3/utilities; ../../../../../devices/MCIMX6G3
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  ICCARM.CCDefines: CPU_MCIMX6G3DVM05; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; EVK_MCIMX6UL
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MCIMX6G3 NXP MCIMX6G3
  ICCARM.CCDefines: NDEBUG; CPU_MCIMX6G3DVM05; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; EVK_MCIMX6UL
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MCIMX6G3xxx05_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h clock_config_ocram.c pin_mux.c pin_mux.h
  group doc
    ../: readme.txt
  group drivers
    ../../devices/MCIMX6G2/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_iomuxc.h fsl_uart.c fsl_uart.h
  group source
    ../: hello_world.c
  group startup
    ../../devices/MCIMX6G2/iar/: startup_MCIMX6G2.s
    ../../devices/MCIMX6G2/: system_MCIMX6G2.c system_MCIMX6G2.h
  group utilities
    ../../devices/MCIMX6G2/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
